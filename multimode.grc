<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multimode</value></param>
<param><key>title</key><value>Multimode Radio Receiver</value></param>
<param><key>author</key><value>Marcus D. Leech (patchvonbraun), Science Radio Laboratories, Inc.</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>max_nouts</key><value>350</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ahw</value></param>
<param><key>label</key><value>Audio Hardware</value></param>
<param><key>value</key><value>default</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>150.0e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>PPM Error</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vol</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ftune</value></param>
<param><key>label</key><value>Fine Tuning</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>xftune</value></param>
<param><key>label</key><value>Extra Fine Tuning</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.0 if muted else volume/4.5</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offs</value></param>
<param><key>label</key><value>LO Offset</value></param>
<param><key>value</key><value>50.e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(int(srate/wbfm)*wbfm)</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>AM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>FM Modes</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>1.0</value></param>
<param><key>center_freq</key><value>offset+fine+xfine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gr_fractional_interpolator_xx</key>
<param><key>id</key><value>gr_fractional_interpolator_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>interp_ratio</key><value>audio_int_rate/arate</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>"/dev/null" if record == False else record_file</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>samp_rate</key><value>int(audio_int_rate)</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>RF Sample Rate</value></param>
<param><key>value</key><value>1.0e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1.25</value></param>
<param><key>samp_rate</key><value>audio_int_rate</value></param>
<param><key>low_cutoff_freq</key><value>100</value></param>
<param><key>high_cutoff_freq</key><value>5.5e3</value></param>
<param><key>width</key><value>2.0e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>int(arate)</value></param>
<param><key>device_name</key><value>ahw</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.gr import firdes</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_d_power</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>display_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adjusted</value></param>
<param><key>value</key><value>"" if int(srate) % int(wbfm) == 0 else " (adjusted)"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>upclo</value></param>
<param><key>label</key><value>Upconverter LO Frequency</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devinfo</value></param>
<param><key>label</key><value>Device Information</value></param>
<param><key>value</key><value>rtl=0</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbfm</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>scan_power</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>rf_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>scan_rate</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>devinfo</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>cur_freq+offset+(upc_offset*float(upc))</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>gain0</key><value>25 if iagc == 1 else rfgain</value></param>
<param><key>gain_mode0</key><value>iagc</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_int_rate</value></param>
<param><key>value</key><value>25e3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import multimode_helper as mh</value></param>
</block>
<block>
<key>gr_feedforward_agc_cc</key>
<param><key>id</key><value>gr_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>0.75</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>agc</value></param>
<param><key>label</key><value>AGC On/Off</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cur_freq</value></param>
<param><key>value</key><value>mh.scan_freq_out(sc_ena,sc_low,sc_high,freq,ifreq,scan_power+1.0e-14,thresh,sc_incr,scan_rate,sc_listm,sc_list)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sc_list_len</value></param>
<param><key>value</key><value>len(sc_list)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sc_list</value></param>
<param><key>value</key><value>eval("["+sc_list_str+"]")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arate</value></param>
<param><key>label</key><value>Audio Sample Rate</value></param>
<param><key>value</key><value>48.0e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>upce</value></param>
<param><key>label</key><value>Upconverter Enabled</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mbw</value></param>
<param><key>label</key><value>AM/SSB Demod Bandwidth</value></param>
<param><key>value</key><value>2.0e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mthresh</value></param>
<param><key>label</key><value>Mute Threshold (dB)</value></param>
<param><key>value</key><value>-10.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>flist</value></param>
<param><key>label</key><value>Frequency Scan List</value></param>
<param><key>value</key><value>""</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>Mute Threshold</value></param>
<param><key>value</key><value>mthresh</value></param>
<param><key>min</key><value>-50</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine</value></param>
<param><key>label</key><value>Fine Tuning</value></param>
<param><key>value</key><value>ftune</value></param>
<param><key>min</key><value>-35e3</value></param>
<param><key>max</key><value>35e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>AM/SSB Bandwidth</value></param>
<param><key>value</key><value>mbw</value></param>
<param><key>min</key><value>1.0e3</value></param>
<param><key>max</key><value>audio_int_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xfine</value></param>
<param><key>label</key><value>Extra Fine Tuning</value></param>
<param><key>value</key><value>xftune</value></param>
<param><key>min</key><value>-1.0e3</value></param>
<param><key>max</key><value>1.0e3</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>RF Level</value></param>
<param><key>value</key><value>float(int(math.log10(rf_d_power+1.0e-14)*100.0)/10.0)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>record</value></param>
<param><key>label</key><value>Record</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>iagc</value></param>
<param><key>label</key><value>AGC</value></param>
<param><key>value</key><value>agc</value></param>
<param><key>true</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sc_low</value></param>
<param><key>label</key><value>Scan Low</value></param>
<param><key>value</key><value>150e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sc_high</value></param>
<param><key>label</key><value>Scan High</value></param>
<param><key>value</key><value>300e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>sc_ena</value></param>
<param><key>label</key><value>Scan Enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>sc_incr</value></param>
<param><key>label</key><value>Scan Increment (Hz)</value></param>
<param><key>value</key><value>12.5e3</value></param>
<param><key>choices</key><value>[5.0e3,6.25e3,10.0e3,12.5e3,15e3,25e3]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>sc_listm</value></param>
<param><key>label</key><value>Scan List Mode</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>upc</value></param>
<param><key>label</key><value>Ext. Upconv.</value></param>
<param><key>value</key><value>upce</value></param>
<param><key>true</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>upc_offset</value></param>
<param><key>label</key><value>Upconv. LO Freq</value></param>
<param><key>value</key><value>upclo</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,2,1,2</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>record_file</value></param>
<param><key>label</key><value>Recording Filename</value></param>
<param><key>value</key><value>"recording.wav"</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,3,1,3</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>LO Offset</value></param>
<param><key>value</key><value>offs</value></param>
<param><key>min</key><value>25e3</value></param>
<param><key>max</key><value>500e3</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ifreq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>vol</value></param>
<param><key>min</key><value>1.0</value></param>
<param><key>max</key><value>10.0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0</value></param>
<param><key>label</key><value>Adjusted Sample Rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>["Main Controls", "Scan/Upconv Controls/Detail"]</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>n</key><value>int(wbfm/audio_int_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>int(samp_rate/wbfm)</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>98e3</value></param>
<param><key>width</key><value>55e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Spectrogram</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>mh.get_last_returned(freq_update)</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>6</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>freqvar</key><value>freq</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Panorama</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>mh.get_last_returned(freq_update)</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>6</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>freqvar</key><value>freq</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>set  to ifreq and regen</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>int(wbfm/audio_int_rate)</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>wbfm</value></param>
<param><key>cutoff_freq</key><value>11.5e3</value></param>
<param><key>width</key><value>5.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1</value></param>
<param><key>label</key><value>Current Scan Freq</value></param>
<param><key>value</key><value>cur_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,2</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sc_list_str</value></param>
<param><key>label</key><value>Scan List</value></param>
<param><key>value</key><value>flist</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,5</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scan_rate</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>display_probe</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>0.005</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>rf_probe</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>0.05</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dmode</value></param>
<param><key>label</key><value>Demod Mode</value></param>
<param><key>value</key><value>NFM1</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0 if mode in am_modes else 0.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>k</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>quad_rate/(2*math.pi*deviation_dict[mode])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation_dict</value></param>
<param><key>value</key><value>{'NFM1' : 5.0e3, 'NFM2' : 2.0e3, 'WFM' : 80e3, 'TV-FM' : 25e3, 'AM' : 9e3, 'USB' : 9e3, 'LSB' : 9e3}</value></param>
</block>
<block>
<key>gr_agc2_xx</key>
<param><key>id</key><value>gr_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-2</value></param>
<param><key>decay_rate</key><value>1e-3</value></param>
<param><key>reference</key><value>0.75</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_rate</value></param>
<param><key>value</key><value>wbfm</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0 if mode in fm_modes else 0.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>SSB/AM Filter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_modes</value></param>
<param><key>value</key><value>["NFM1", "NFM2", "WFM", "TV-FM"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_modes</value></param>
<param><key>value</key><value>["AM"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logpower</value></param>
<param><key>value</key><value>math.log10(rf_power+1.0e-12)*10.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>muted</value></param>
<param><key>value</key><value>0.0 if logpower &gt;= thresh else 1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_power</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>rf_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.25 if mode in ssb_modes else 0.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ssb_modes</value></param>
<param><key>value</key><value>["USB", "LSB"]</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>mode</value></param>
<param><key>label</key><value>Mode</value></param>
<param><key>value</key><value>dmode</value></param>
<param><key>choices</key><value>fm_modes+am_modes+ssb_modes</value></param>
<param><key>labels</key><value>fm_mode_labels+am_modes+ssb_modes</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>blks2_fm_deemph</key>
<param><key>id</key><value>blks2_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>audio_int_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>int(quad_rate/audio_int_rate)</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>wbfm</value></param>
<param><key>cutoff_freq</key><value>11.5e3</value></param>
<param><key>width</key><value>4e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>wbfm</value></param>
<param><key>cutoff_freq</key><value>deviation_dict[mode]*1.15</value></param>
<param><key>width</key><value>deviation_dict[mode]/2.0</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_mode_labels</value></param>
<param><key>value</key><value>["NFM1(5kHz)", "NFM2(2.5Khz)", "WFM(80Khz)", "TV-FM(25Khz)"]</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_update</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>rf_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1.0/(2.5)</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_int_rate</value></param>
<param><key>low_cutoff_freq</key><value>am_filt_dict_low[mode]</value></param>
<param><key>high_cutoff_freq</key><value>am_filt_dict_high[mode]</value></param>
<param><key>width</key><value>bw/3.5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_filt_dict_high</value></param>
<param><key>value</key><value>{'AM' : bw/2, 'USB' : bw/2, 'LSB': -bw/12, 'NFM1' : bw/2, 'NFM2' : bw/2, 'WFM' : bw/2, 'TV-FM' : bw/2}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_filt_dict_low</value></param>
<param><key>value</key><value>{'AM' : -bw/2, 'USB' : bw/12, 'LSB': -bw/2, 'NFM1' : -bw/2, 'NFM2' : -bw/2, 'WFM' : -bw/2, 'TV-FM' : -bw/2}</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Detailed Spectrum</value></param>
<param><key>samp_rate</key><value>audio_int_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.250</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Detailed Spectrogram</value></param>
<param><key>samp_rate</key><value>audio_int_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>40</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_fractional_interpolator_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_feedforward_agc_cc_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2</source_block_id><sink_block_id>blks2_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0</source_block_id><sink_block_id>gr_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>gr_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>display_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>rf_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_feedforward_agc_cc_0</source_block_id><sink_block_id>gr_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>low_pass_filter_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
